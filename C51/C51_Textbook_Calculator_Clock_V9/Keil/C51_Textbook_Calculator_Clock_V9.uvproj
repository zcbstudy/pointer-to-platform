# Keil uVision project C51_Textbook_Calculator_Clock_V9.uvproj, settings and files
target AT89C52_MultiFunction (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: C51_MultiFunction_System +hex
  c flags: Optimize=6 SizeSpeed=1
  group USER
    ../Source/: main.c
  group HARDWARE
    ../Source/: timer.c segment.c matrix.c key.c buzzer.c led.c
  group APPLICATION
    ../Source/: calculator.c clock.c
